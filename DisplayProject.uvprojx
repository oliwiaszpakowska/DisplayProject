# Keil uVision project DisplayProject.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DisplayProject +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group cfiles
    ./: main.c
    D:/Programowanie/ProjektyOliwia/Display/cfiles/: clock_configuration.c
    ./cfiles/: system_utilities.c GPIO_configuration.c
  group headers
    D:/Programowanie/ProjektyOliwia/Display/headers/: clock_configuration.h preprocessor_directives.h GPIO_configuration.h
    ./headers/: system_utilities.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.11.2
